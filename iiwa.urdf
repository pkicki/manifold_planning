Commit message: Torque loss in tensorflow

File: iiwa.urdf (robot description, URDF)
Before this commit: robot iiwa, 9 links, 8 joints
Links:
- added link F_link_ee, mass 0.0
Joints:
- added joint F_joint_ee: type fixed, parent F_link_7, child F_link_ee, origin xyz=0 0 0.07 rpy=0 0 0
